## sdkconfig.defaults
```kconfig
CONFIG_I2S_ENABLE_DEBUG_LOG=y
CONFIG_I2S_DATA_GPIO=2
CONFIG_I2S_WS_GPIO=42
CONFIG_I2S_CLK_GPIO=41
CONFIG_I2S_NUM_0=y
```
